<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\c8t6oled.ewp</path>
  </project>
  <batchBuild />
</workspace>
